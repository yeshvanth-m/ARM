# Keil uVision project nRF5340DK.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: nRF5340_xxAA:Application Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x0003F000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x08000000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: nRF5340DK
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=4
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x3f000
  group Source Group 1
    ../src/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
